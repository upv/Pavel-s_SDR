options:
  parameters:
    author: Jay Patel
    category: Custom
    copyright: '2020'
    description: FM Radio PlutoSDR
    generate_options: qt_gui
    id: top_block
    output_language: python
    realtime_scheduling: '1'
    title: FM Radio PlutoSDR
  states: {}

blocks:
- name: fm_station
  id: variable_qtgui_range
  parameters:
    label: station
    rangeType: int
    start: int(92e6)
    step: int(10000)
    stop: int(106e6)
    value: int(100.1e6)
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '2800000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: '384000'
  states: {}
- name: audio_device
  id: parameter
  parameters:
    label: Audio device
    type: str
    value: default
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_device
    samp_rate: '48000'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '1'
  states: {}
- name: fm_station
  id: parameter
  parameters:
    label: FM station
    type: eng_float
    value: 100.1e6
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '0x20000'
    filter_source: '''Auto'''
    frequency: fm_station
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '44100'
    decim: sample_rate // (384000 * decimation)
    gain: '1'
    samp_rate: int(sample_rate / decimation)
    type: fir_filter_ccf
    width: '44100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: fm_station
    fftsize: '1024'
    name: Receive Signal
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: fm_station
    fftsize: '2048'
    grid: 'True'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:pluto.local
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
