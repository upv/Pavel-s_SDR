options:
  parameters:
    generate_options: qt_gui
    id: Spectrum
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Central_Frequency
  id: variable
  parameters:
    value: int(2190e6)
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: int(30.72e6)
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: Central_Frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: int(sample_rate)
    center_freq: Central_Frequency
    dev_args: 192.168.2.2
    gain: '73'
    samp_rate: sample_rate
    type: fc32
  states: {}

connections:
- [soapy_plutosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
