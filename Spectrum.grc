options:
  parameters:
    generate_options: qt_gui
    id: Spectrum
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Central_Frequency
  id: variable
  parameters:
    value: int(1190e6)
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '1500000'
    bbdc: 'True'
    buffer_size: int(8200)
    filter_source: '''Auto'''
    frequency: int(100e6)
    gain1: '''manual'''
    manual_gain1: '100'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: 192.168.2.2
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: Central_Frequency
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
